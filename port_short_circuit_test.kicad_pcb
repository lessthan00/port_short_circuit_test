# Repository lessthan00/port_short_circuit_test

File README.md:

# port_short_circuit_test

USBA,USBC,RJ45,DB6 这些常用的信号接口, 引出引脚为 2.54mm的排针, 方便测试信号和检测焊接是否短路.

## KiCad design port_short_circuit_test.kicad_pcb

Parts:
J1: USB3_A; USB3_A_Molex_48393-001
J2: USB_C_Receptacle; USB_C_Receptacle_Amphenol_12401548E4-2A
J3, J7, J8, J9: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J4: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
J5: DE9_Socket; DSUB-9_Socket_Vertical_P2.77x2.84mm_MountingHoles
J6: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J10: 8P8C_Shielded; RJ45_Amphenol_RJHSE5380

Connections:
/1: J5.1, J8.1
/2: J5.2, J8.3
/3: J5.3, J8.5
/4: J5.4, J8.7
/4A6-D+: J6.A6 (D+), J7.4
/4A7-D-: J6.A7 (D-), J7.5
/4B6-D+: J6.B6 (D+), J7.6
/4B7-D-: J6.B7 (D-), J7.3
/4CC1: J6.A5 (CC1), J7.2
/4CC2: J6.B5 (CC2), J7.8
/4GND: J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J7.10
/4SBU1: J6.A8 (SBU1), J7.7
/4SBU2: J6.B8 (SBU2), J7.1
/4SHIELD: J6.S1 (SHIELD)
/4VBUS: J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS), J7.9
/5: J5.5, J8.9
/6: J5.6, J8.2
/7: J5.7, J8.4
/8: J5.8, J8.6
/9: J5.9, J8.8
/A6-D+: J2.A6 (D+), J4.9
/A7-D-: J2.A7 (D-), J4.11
/B6-D+: J2.B6 (D+), J4.12
/B7-D-: J2.B7 (D-), J4.10
/CC1: J2.A5 (CC1), J4.7
/CC2: J2.B5 (CC2), J4.16
/D+: J1.3 (D+), J3.5
/D-: J1.2 (D-), J3.3
/DRAIN: J1.7 (DRAIN), J3.6
/GND: J1.4 (GND), J3.7
/GND2: J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J4.1, J4.19
/RX1+: J2.B11 (RX1+), J4.2
/RX1-: J2.B10 (RX1-), J4.4
/RX2+: J2.A11 (RX2+), J4.17
/RX2-: J2.A10 (RX2-), J4.15
/RX+: J9.6, J10.3
/RX-: J9.7, J10.6
/SBU1: J2.A8 (SBU1), J4.13
/SBU2: J2.B8 (SBU2), J4.6
/SHIELD: J1.10 (SHIELD), J3.9
/SHIELD2: J2.S1 (SHIELD)
/SHIELD3: J9.2, J10.SH
/SSRX+: J1.6 (SSRX+), J3.8
/SSRX-: J1.5 (SSRX-), J3.10
/SSTX+: J1.9 (SSTX+), J3.2
/SSTX-: J1.8 (SSTX-), J3.4
/TX1+: J2.A2 (TX1+), J4.3
/TX1-: J2.A3 (TX1-), J4.5
/TX2+: J2.B2 (TX2+), J4.20
/TX2-: J2.B3 (TX2-), J4.18
/TX+: J9.4, J10.1
/TX-: J9.3, J10.2
/VBUS: J1.1 (VBUS), J3.1
/VBUS2: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), J4.8, J4.14
unnamed: J9.5, J10.4
unnamed: J9.8, J10.5
unnamed: J9.9, J10.8
unnamed: J9.10, J10.7

Notes on the sheet:
RS485-A
RS232_RXD
RS-422（差分通信） 协议：差分信号，抗干扰强，支持全双工。 典型应用：工业长距离通信。 引脚定义（需适配器或专用接口）： 引脚 信号 说明 1 TX+ 发送数据（+） 2 TX- 发送数据（-） 3 RX+ 接收数据（+） 4 RX- 接收数据（-） 5 GND 信号地 注：RS-422 通常使用 DB9 的 4 个引脚（1, 2, 3, 4）实现差分对。
RS232_TXD
RS-422_TX-
RS-422_RX-
RS485-B
RS-232（常见标准） 协议：异步串行通信（UART），用于点对点通信。 典型应用：老式计算机串口、工业设备、调制解调器。 引脚定义（DTE 设备视角，如计算机）： 引脚 信号 方向 说明 1 CD 输入 载波检测（未常用） 2 RXD 输入 接收数据 3 TXD 输出 发送数据 4 DTR 输出 数据终端就绪 5 GND - 信号地 6 DSR 输入 数据设备就绪 7 RTS 输出 请求发送 8 CTS 输入 清除发送 9 RI 输入 振铃指示（未常用） 最小连接（仅通信）： 2 (RXD)、3 (TXD)、5 (GND)。
RS-422_TX+
RS-485（多设备总线） 协议：半双工差分通信，支持多节点。 典型应用：工业总线（如 Modbus RTU）。 引脚定义： 引脚 信号 说明 1 Data+(A) 差分数据（+） 2 Data-(B) 差分数据（-） 5 GND 信号地 注：RS-485 通常仅需 2 根数据线（+/-）和地线。
GND
2. 两种标准线序（T568A vs T568B） 引脚 T568A 线序（颜色） T568B 线序（颜色） 信号功能（100BASE-TX） Pin 1 白绿 (WG) 白橙 (WO) TX+ (发送数据+) Pin 2 绿 (G) 橙 (O) TX- (发送数据-) Pin 3 白橙 (WO) 白绿 (WG) RX+ (接收数据+) Pin 4 蓝 (BL) 蓝 (BL) 未使用（或语音） Pin 5 白蓝 (WBL) 白蓝 (WBL) 未使用（或语音） Pin 6 橙 (O) 绿 (G) RX- (接收数据-) Pin 7 白棕 (WBR) 白棕 (WBR) 未使用 Pin 8 棕 (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

Board: 2 copper layers, 100.0 x 29.0 mm, 10 parts (0 on the bottom side), 56 nets.
